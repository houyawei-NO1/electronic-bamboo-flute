# Keil uVision project electronic-bamboo-flute.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: electronic-bamboo-flute +hex
  group app
    ./usr/: main.c
  group library
    ./library/: STC32G_GPIO.c STC32G_Delay.c
